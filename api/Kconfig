## api/Kconfig
```kconfig
menu "API"

config API
	bool "Enable U-Boot API"
	default n
	help
	  This option enable the U-Boot API.

endmenu
```
